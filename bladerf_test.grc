options:
  parameters:
    generate_options: qt_gui
    id: bladerf_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '4096'
    bw: 1.5e6
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: '0'
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: 903.7e6
    gain0: '10'
    gain1: '10'
    gain_mode0: 'True'
    gain_mode1: 'True'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '2'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_0_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '79980'
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/joannas/samples.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/joannas/testnonprbs_chip16_30squares_ch1.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/joannas/testprbschip11_ch2.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/joannas/interferencelosstest_ant1_0524.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_2
  id: blocks_file_sink
  parameters:
    file: /home/joannas/interferencelosstest_ant2_0524.bin
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '20'
    max_iter: '4000'
    scale: '.05'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '20'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=0,agc_mode=slow,rxmux=baseband"'
    bb_gain0: '10'
    bb_gain1: '10'
    bw0: 4e6
    bw1: 4e6
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: 914.8e6
    freq1: 914.8e6
    gain0: '20'
    gain1: '20'
    gain_mode0: 'True'
    gain_mode1: 'True'
    if_gain0: '10'
    if_gain1: '10'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: 8e6
    sync: none
    time_source0: gpsdo
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 8e6
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '16384'
    nconnections: '2'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    nconnections: '2'
    size: 1024*16
    srate: samp_rate
    type: complex
    update_time: '0.1'
    ymax: '.05'
    ymin: '-.05'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    size: 1024*20
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '.05'
    ymin: '-.05'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    size: 1024*20
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '.05'
    ymin: '-.05'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: fff
  states: {state: disabled}

connections:
- [bladeRF_source_0, '0', blocks_complex_to_float_0, '0']
- [bladeRF_source_0, '0', blocks_complex_to_magphase_0_0_0_0, '0']
- [bladeRF_source_0, '0', blocks_file_sink_0_0_1, '0']
- [bladeRF_source_0, '0', qtgui_freq_sink_x_0, '0']
- [bladeRF_source_0, '0', qtgui_time_sink_x_1_0, '0']
- [bladeRF_source_0, '1', blocks_file_sink_0_0_2, '0']
- [bladeRF_source_0, '1', qtgui_freq_sink_x_0, '1']
- [bladeRF_source_0, '1', qtgui_time_sink_x_1_0, '1']
- [blocks_complex_to_float_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '1', blocks_file_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_magphase_0_0_0_0, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_complex_to_magphase_0_0_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_moving_average_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_moving_average_xx_0_1, '0', qtgui_time_sink_x_1_0_0, '0']
- [osmosdr_source_0_0, '0', blocks_complex_to_float_0, '0']
- [osmosdr_source_0_0, '0', blocks_file_sink_0_0, '0']
- [osmosdr_source_0_0, '0', blocks_file_sink_0_0_1, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [osmosdr_source_0_0, '1', blocks_complex_to_magphase_0_0_0_0, '0']
- [osmosdr_source_0_0, '1', blocks_file_sink_0_0_0, '0']
- [osmosdr_source_0_0, '1', blocks_file_sink_0_0_2, '0']
- [osmosdr_source_0_0, '1', qtgui_freq_sink_x_0, '1']
- [osmosdr_source_0_0, '1', qtgui_time_sink_x_1_0, '1']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_1_0_0_0, '0']

metadata:
  file_format: 1
